# Keil uVision project Project.uvprojx, settings and files
target generalVer-8pLed (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32F0301MF4P7C HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: D7ledBoardProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F0301MXXC , HK32F0301MF4P7C,USE_HK32F0301MF4P7C_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\userLib\inc;..\userLib\src;..\Libraries\CMSIS\CM0\Core;..\Libraries\CMSIS\HK32F0301MxxC\Include;..\Libraries\CMSIS\HK32F0301MxxC\Source\ARM;..\Libraries\CMSIS\HK32F0301MxxC\Source;..\Libraries\HK32F0301MxxC_StdPeriph_Driver\inc;..\Libraries\HK32F0301MxxC_StdPeriph_Driver\src;..\Boards\Board_HK32F0301MF4P7C_EVAL\inc;..\Boards\Board_HK32F0301MF4P7C_EVAL\src;..\inc;..\src;..\Boards
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../Libraries/CMSIS/HK32F0301MxxC/Source/: system_hk32f0301mxxc.c
    ../Libraries/CMSIS/HK32F0301MxxC/Source/ARM/: KEIL_Startup_hk32f0301mxxc.s
  group User
    ../src/: main.c hk32f0301mxxc_it.c
  group StdPeriph_Driver
    ../Libraries/HK32F0301MxxC_StdPeriph_Driver/src/: hk32f0301mxxc_adc.c hk32f0301mxxc_awut.c hk32f0301mxxc_crc.c hk32f0301mxxc_dbgmcu.c hk32f0301mxxc_exti.c hk32f0301mxxc_flash.c hk32f0301mxxc_gpio.c hk32f0301mxxc_i2c.c hk32f0301mxxc_iwdg.c hk32f0301mxxc_misc.c hk32f0301mxxc_pwr.c hk32f0301mxxc_rcc.c hk32f0301mxxc_spi.c hk32f0301mxxc_syscfg.c hk32f0301mxxc_tim.c hk32f0301mxxc_uart.c hk32f0301mxxc_wwdg.c
  group Board
    ../Boards/: l_uart.c l_gpio.c
  group userLib
    ../userLib/src/: f_idle.c l_u8FIFO.c l_sysProcess.c l_timer.c l_arch.c l_jsonTL.c l_actionFIFO.c l_rs485.c
